# IAR project PR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: Abstract_Hardware; Abstract_Hardware\Atomic; Abstract_Hardware\InterruptHandler; Abstract_Hardware\Registers; Abstract_Hardware\Registers\STM32F411; Abstract_Hardware\Registers\STM32F411\FieldValues; Application; Common; FreeRtos
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: PR.srec
  ILINK.IlinkOutputFile: PR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ./: main.cpp startup.cpp
    Debug/List/: PR.map
